# Keil uVision project a.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89LPC922 NXP
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000) MODP2
  output: a +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: START900.A51 main.c utilities.h utilities.c
